# Keil uVision project code.uvproj, settings and files
target BalanceBattery (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: BalanceBattery +hex
  link misc: REMOVEUNUSED
  group App
    ./app/: app.c init.c server.c
  group library
    ./library/: STC32G_Delay.c STC32G_GPIO.c STC32G_Timer.c STC32G_Timer_Isr.c STC32G_NVIC.c STC32G_UART.c STC32G_UART_Isr.c STC32G_Soft_I2C.c STC32G_ADC.c STC32G_DMA.c STC32G_PWM.c
  group drive
    ./drive/: oled.c oledfont.c key.c
