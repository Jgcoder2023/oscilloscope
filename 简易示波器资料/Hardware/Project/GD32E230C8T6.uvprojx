# Keil uVision project GD32E230C8T6.uvprojx, settings and files
target Oscilloscope (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: GD32E230
  c misc: -Wno-invalid-source-encoding
  c include: ..\Firmware\GD32E23x_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32E23x\Include;..\Firmware\CMSIS;..\App;..\Lib\LedKey;..\Lib\System;..\Lib\Timer;..\Lib\Usart;..\Lib\Lcd;..\Lib\Adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
    ../Firmware/CMSIS/GD/GD32E23x/Include/: gd32e23x.h
    ../Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Include/: gd32e23x.h system_gd32e23x.h
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group App
    ../App/: main.c main.h show.c show.h
  group Lib\System
    ../Lib/System/: gd32e23x_it.c gd32e23x_it.h gd32e23x_libopt.h systick.c systick.h
  group Lib\Timer
    ../Lib/Timer/: timer.c timer.h timerPwm.c timerPwm.h timer15.c timer15.h freq.c freq.h timerDac.c timerDac.h
  group Lip\LedKey
    ../Lib/LedKey/: key.c key.h led.c led.h ec11.c ec11.h signalRelay.c signalRelay.h
  group Lib\Usart
    ../Lib/Usart/: usart.c usart.h
  group Lib\Lcd
    ../Lib/Lcd/: font.h pic.h tft.c tft.h tft_init.c tft_init.h
  group Lib\Adc
    ../Lib/Adc/: adc.c adc.h
software components: CMSIS:CORE 5.6.0
